# Keil uVision project Firmware_Library.uvprojx, settings and files
target HNUST-103 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Firmware_Library +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\Template_REG2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: stm32f10x.h main.c startup_stm32f10x_md.s stm32f10x_gpio.c
